## drivers/net/wireless/rockchip_wlan/rtl8821cs/Kconfig
```kconfig
config RTL8821C
	bool "Realtek 8821CS SDIO WiFi"
	help
	  Help message of RTL8821C
```
